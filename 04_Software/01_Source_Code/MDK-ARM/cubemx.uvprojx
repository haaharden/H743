# Keil uVision project cubemx.uvprojx, settings and files
target cubemx (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: cubemx +hex
  AfterMake: fromelf --bin --output .\Objects\app.bin .\Objects\cubemx.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=4
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/inc;../Platform/inc;../Tasks/Inc;../SYSTEM;../BSP/disp_ht05;../BSP/touch_gt1151q;../BSP/flash_w25q256;../BSP/sdram;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/RTOS2/Include;../OS/FreeRTOS/Source/include;../OS/FreeRTOS/Source/CMSIS_RTOS_V2;../OS/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../OS/FreeRTOS/Source/portable/Common;../Middlewares/FatFs/src;../Middlewares/STM32_USB_Host_Library/Class/MSC/Inc;../Middlewares/STM32_USB_Host_Library/Core/Inc;../Middlewares/LVGL/GUI;../Middlewares/LVGL/GUI/src;../Middlewares/LVGL/GUI/porting;../Middlewares/LVGL/GUI_APP/gui/test/custom;../Middlewares/LVGL/GUI_APP/gui/test/generated;../Middlewares/RTT;..\Tasks\disp;..\Tasks\usb;..\BSP\flash_board;..\Tasks;..\Tasks\ota
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\cubemx.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
    ./: cubemx.sct
  group Application/User
    ../Core/src/: main.c gpio.c freertos.c dma2d.c fatfs.c fmc.c i2c.c ltdc.c quadspi.c rtc.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c usb_host.c usbh_conf.c userh_diskio.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c
  group Drivers/CMSIS
    ../Core/src/: system_stm32h7xx.c
  group BSP
    ../BSP/flash_w25q256/: flash_w25q256.c
    ../BSP/sdram/: sdram_w9825g6.c
    ../BSP/touch_gt1151q/: touch_gt1151q.c
    ../BSP/flash_board/: flash_if.c
  group Middlewares/FatFs
    ../Middlewares/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../OS/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../OS/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../OS/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Host_library
    ../Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middleware/LVGL/src
    ../Middlewares/LVGL/GUI/: lvgl.h
    ../Middlewares/LVGL/GUI/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/GUI/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/GUI/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL/GUI/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/LVGL/GUI/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/GUI/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/GUI/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Middlewares/LVGL/GUI/src/extra/: lv_extra.c
    ../Middlewares/LVGL/GUI/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/GUI/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/GUI/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/GUI/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/GUI/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/GUI/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/GUI/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/GUI/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/GUI/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/GUI/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/GUI/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/LVGL/GUI/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/GUI/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/GUI/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/GUI/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/GUI/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/GUI/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL/GUI/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/GUI/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/GUI/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/GUI/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/GUI/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middleware/LVGL/port
    ../Middlewares/LVGL/GUI/: lv_conf.h
    ../Middlewares/LVGL/GUI/porting/: lv_port_disp.c lv_port_indev.c lv_port_fs.c lv_port_flash_fs.c
  group gui
    ../Middlewares/LVGL/GUI_APP/gui/test/custom/: gui_test_app.c custom.c
    ../Middlewares/LVGL/GUI_APP/gui/test/generated/: events_init.c gui_guider.c setup_scr_screen_home.c setup_scr_screen_1.c widgets_init.c setup_scr_screen_2.c
    ../Middlewares/LVGL/GUI_APP/gui/test/generated/guider_fonts/: lv_font_montserratMedium_18.c lv_font_montserratMedium_16.c lv_font_AlimamaDongFangDaKai_Regular_18.c
  group Svc
    ../Tasks/Src/: initial.c
    ../BSP/disp_ht05/: disp_ht05.c
  group RTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group APP
    ../Tasks/disp/: display.c
    ../Tasks/usb/: usb_storage.c usb_file_browser.c
    ../Tasks/ota/: ota_update.c
    ../Tasks/: event_conf.h
software components: CMSIS:CORE 5.6.0
